# Keil uVision project USB_IAP.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: USB_IAP +hex
  AfterMake: fromelf.exe --bin -o USB_IAP.bin ./output/USB_IAP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../sdk/bundles/noos_mini/inc;../../sdk/bundles/noos_mini/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src;.\src\IAP;.\src\USB_IAP;.\src\common;.\src\app;.\src\bsp;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20004940 size 0x96c0
  group APP
    ./src/: main.c profile.c noos_impl.c
    ./src/app/: app_main.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../sdk/bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../sdk/src/BSP/: eflash.c
    ./src/bsp/: bsp_usb_hid_iap.c
  group FWlib
    ../../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../sdk/src/Tools/: trace.c
  group IAP
    ./src/IAP/: IAP_916.c IAP_Application.c IAP_Bootloader.c IAP_Flash_WP.c IAP_Transport.c
  group common
    ./src/common/: crc16.c
software components: CMSIS:CORE 4.3.0
